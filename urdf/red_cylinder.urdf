Commit message: Changes to two_scara for the example env

File: urdf/red_cylinder.urdf (robot description, URDF)
Before this commit: robot red_cylinder, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.08 radius=0.04; visual cylinder length=0.08 radius=0.04
